TARGET_CFLAGS += " -D_TIME_BITS=64 -D_FILE_OFFSET_BITS=64"
